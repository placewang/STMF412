# Keil uVision project E457_STM32F205.uvprojx, settings and files
target E490_205 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F205ZETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: E457_STM32F205 +hex
  c flags: Optim=2 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: SUPPORT_1S,STM32_BOARD
  c include: ..\..\arch_STM32103\inc;..\..\core\inc;..\..\arch_STM32103\lib\inc;D:\keilpacks\Keil\STM32F2xx_DFP\2.9.0\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x1f000
  memory RVCT10: RAM 0x2001f000 size 0x1000
  group src
    ../../core/src/: alert.c main.c massage.c step.c ver.c encoder.c hq_can_key.c
    ../../arch_STM32103/src/: adc.c arch_stm32.c can.c coder.c eeprom.c exti.c fsmc.c gpio.c iwdg.c stm32f2xx_it.c time.c uart.c arch_dma.c
    ../../misc/: dprintf.c commands.c
    ../../SShell/: shell.c
    ../../arch_STM32103/src_boot/: upgrade.c
  group lib
    ../../arch_STM32103/lib/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c system_stm32f2xx.c
  group start
    ../../arch_STM32103/lib/startup/MDK/: startup_stm32f2xx.s
target E490_GD407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F205RETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: E490_GD32F407 +hex
  AfterMake: E:\work\HJ_Head_E475_STM32F205\prj-STM32\mk_aftb_GD407.bat
  c flags: Optim=2 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: SUPPORT_1S,STM32_BOARD
  c include: C:\Keil_v5\ARM\Pack\Keil\STM32F2xx_DFP\2.9.0\Drivers\CMSIS\Include;..\..\arch_STM32103\inc;..\..\core\inc;..\..\arch_STM32103\lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.5.0, Device:Startup 2.2.1
